## package/python-smbus/Config.in
```kconfig
config BR2_PACKAGE_PYTHON_SMBUS
	bool "python-smbus"
	depends on BR2_PACKAGE_PYTHON
	help
	  This module allows access to the SMBus
```
